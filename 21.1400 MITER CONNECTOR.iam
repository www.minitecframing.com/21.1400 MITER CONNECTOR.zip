# Autodesk Inventor assembly: 21_1400
## iProperties
Created: 2006-12
Part Number: 21_1400
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
